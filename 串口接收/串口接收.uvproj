# Keil uVision project 串口接收.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 串口接收 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h UART.c UART.h main.c
